INTERFACE I_SignalHandling

METHOD PUBLIC Enable
VAR_INPUT
	bEnable		: BOOL;
END_VAR
END_METHOD

METHOD SetOutput
VAR_INPUT
END_VAR
END_METHOD

END_INTERFACE
