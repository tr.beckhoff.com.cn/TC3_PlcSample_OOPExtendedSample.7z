{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_StateSortingAutoAxis :
(
	WaitForCylinderAtWorkPos := 0,
	MoveAxis,
	StopAxis
);
END_TYPE
