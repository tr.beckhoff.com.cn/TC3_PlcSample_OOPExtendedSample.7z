{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_StateSortingAutoCylinder :
(
	DetectBox := 0,
	CylToWork,
	CylToBase
);
END_TYPE
