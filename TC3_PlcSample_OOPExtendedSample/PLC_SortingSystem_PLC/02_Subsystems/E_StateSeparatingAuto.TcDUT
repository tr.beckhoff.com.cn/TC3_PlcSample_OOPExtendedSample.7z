{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_StateSeparatingAuto :
(
	Init := 0,
	Start,
	CloseClamp,
	OpenBarrier,
	CloseBarrier,
	OpenClamp
);
END_TYPE
